# Keil uVision project CIMC_GD32_fatfs_driver.uvprojx, settings and files
target APP (6230000::V6.23::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Function;..\Driver;..\CMSIS\GD\GD32F4xx\Include;..\Driver\LED;..\Driver\USART;..\Driver\ADC;..\Driver\DMA;..\Driver\I2C;..\Driver\KEY;..\Driver\Fatfs;..\Driver\OLED;..\Driver\SPI;..\Driver\DAC;..\Driver\SDCARD;..\Driver\SPI_FLASH;..\Driver\RTC;..\Driver\SPI_PORT;..\Protocol;..\Driver\485;..\Driver\RINGBUFFER;..\Driver\FLASH_PARTITION;..\Driver\PARAM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\APP.sct
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Driver
    ../Driver/LED/: LED.c LED.h
    ../Driver/USART/: USART.c USART.h
    ../Driver/SDCARD/: sdcard.h sdcard.c
    ../Driver/ADC/: ADC.c ADC.h
    ../Driver/DMA/: dma.c dma.h
    ../Driver/I2C/: i2c.h i2c.c
    ../Driver/KEY/: key.c key.h
    ../Driver/MALLOC/: malloc.c malloc.h
    ../Driver/NORFLASH/: norflash.c norflash.h
    ../Driver/OLED/: OLED.h OLED.c OLEDfont.h
    ../Driver/SPI_FLASH/: SPI_FLASH.c SPI_FLASH.h
    ../Driver/SPI/: spi.h spi.c
    ../Driver/GD30AD3344_standard_peripheral/Include/: gd30ad3344.h spi_def.h spi_port.h
    ../Driver/GD30AD3344_standard_peripheral/Source/: gd30ad3344.c
    ../Driver/SPI_PORT/: spi_port.c
    ../Driver/Fatfs/: ff.c ffconf.h diskio.c
    ../Driver/485/: 485.c 485.h
    ../Driver/DAC/: dac.c dac.h
    ../Driver/RINGBUFFER/: ringbuffer.c ringbuffer.h
    ../Driver/FLASH_PARTITION/: flash_partition.h
    ../Driver/PARAM/: param.h param.c
  group Protocol
    ../Protocol/: ModbusCRC.c ModbusCRC.h
  group Function
    ../Function/: Function.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
software components: CMSIS:CORE 6.1.0
